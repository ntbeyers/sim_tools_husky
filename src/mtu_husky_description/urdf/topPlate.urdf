Commit message: Working 4 robot demo

File: src/mtu_husky_description/urdf/topPlate.urdf (robot description, URDF)
Before this commit: robot topPlate, 1 links, 1 joints
Links:
- link topPlate: geometry collision box size=.5 .5 .5; visual mesh filename=package://mtu01_husky/meshes/doublePlate.STL
