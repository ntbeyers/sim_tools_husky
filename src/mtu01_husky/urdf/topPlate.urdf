Commit message: Added model changes for ROS indigo

File: src/mtu01_husky/urdf/topPlate.urdf (robot description, URDF)
Before this commit: robot topPlate, 1 links, 1 joints
Joints:
- joint base_link_to_topPlate: origin xyz=0.0 0.0 0.2503 rpy=0.0 0.0 0.0 -> xyz=0.0812 0.0 0.245 rpy=0.0 0.0 0.0
